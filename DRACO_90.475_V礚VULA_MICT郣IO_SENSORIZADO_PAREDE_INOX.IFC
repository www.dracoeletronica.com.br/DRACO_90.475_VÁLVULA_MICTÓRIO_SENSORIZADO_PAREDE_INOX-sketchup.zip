Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_90.475_VÁLVULA_MICTÓRIO_SENSORIZADO_PAREDE_INOX.IFC
Time: 2023-06-14T15:02:44
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
